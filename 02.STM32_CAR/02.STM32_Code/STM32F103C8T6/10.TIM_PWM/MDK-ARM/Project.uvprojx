# Keil uVision project Project.uvprojx, settings and files
target Project (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\CMSIS-DRIVER\CMSIS\CoreSupport;..\CMSIS-DRIVER\CMSIS\DeviceSupport;..\CMSIS-DRIVER\CMSIS\DeviceSupport\startup;..\CMSIS-DRIVER\STM32F10x_StdPeriph_Driver\inc;..\CMSIS-DRIVER\STM32F10x_StdPeriph_Driver\src;..\USER-CODE
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER-CODE
    ../USER-CODE/: main.c BSP_LED.c BSP_LED.h BSP_KEY.c BSP_KEY.h BSP_KEY_EXTI.c BSP_KEY_EXTI.h BSP_USART.c BSP_USART.h BSP_USART_IT.c BSP_USART_IT.h BSP_TIM_Base.c BSP_TIM_Base.h BSP_TIM_PWM.c BSP_TIM_PWM.h BSP_SysTick.c BSP_SysTick.h stm32f10x_it.c stm32f10x_it.h stm32f10x_conf.h
  group CMSIS-DRIVER\CMSIS\CoreSupport
    ../CMSIS-DRIVER/CMSIS/CoreSupport/: core_cm3.c core_cm3.h
  group CMSIS-DRIVER\CMSIS\DeviceSupport
    ../CMSIS-DRIVER/CMSIS/DeviceSupport/: stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group CMSIS-DRIVER\CMSIS\DeviceSupport\startup
    ../CMSIS-DRIVER/CMSIS/DeviceSupport/startup/: startup_stm32f10x_md.s
  group CMSIS-DRIVER\STM32F10x_StdPeriph_Driver\inc
    ../CMSIS-DRIVER/STM32F10x_StdPeriph_Driver/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
  group CMSIS-DRIVER\STM32F10x_StdPeriph_Driver\src
    ../CMSIS-DRIVER/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
